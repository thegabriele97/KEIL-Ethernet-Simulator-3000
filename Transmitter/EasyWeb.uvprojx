# Keil uVision project EasyWeb.uvprojx, settings and files
target MCB1700 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EasyWeb +hex
  c flags: Optim=1
  c define: __FLASH
  c include: C:\Users\gabri\AppData\Local\Arm\Packs\ARM\CMSIS\5.7.0\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group HTML Source
    ./: webpage.html
  group Configuration Files
    ./: startup_LPC17xx.s system_LPC17xx.c tcpip.h
  group EasyWeb
    ./: tcpip.c EMAC.c easyweb.c Retarget.c easyweb.h
  group Documentation
    ./: Abstract.txt
