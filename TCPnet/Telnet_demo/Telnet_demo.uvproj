# Keil uVision project Telnet_demo.uvproj, settings and files
target MCB1700 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Telnet_demo
  c flags: Optim=1
  c include: ..\Library
  asm include: D:\Softwares_OS\Keil_v5\ARM\RV31\LIB
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Files
    ./: Telnet_demo.c Telnet_uif.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c startup_LPC17xx.s
  group Library
    D:/Softwares_OS/Keil_v5/ARM/RV31/LIB/: TCP_CM3.lib TCPD_CM3.lib
    ../Library/: EMAC_LPC17xx.c GLCD_SPI_LPC1700.c system_LPC17xx.c
  group Documentation
    ./: Abstract.txt
target MCB1700 Debug (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: Telnet_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
